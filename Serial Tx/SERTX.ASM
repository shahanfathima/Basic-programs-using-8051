	ORG 200H
TABLE:  
    DB 'H', 'E', 'L', 'L','O',13		
	ORG 00
MOV SCON,#50H
MOV TMOD,#20H
MOV TH1,#0FDH
MOV TL1,#0FDH
SETB TR1
MAIN:	
MOV R0,#6h   
MOV R2,#00H
MOV DPTR, #TABLE 
LOOP0:
MOV A,R2
MOVC A, @A+DPTR   
MOV SBUF,A
WAIT: JNB TI,WAIT
CLR TI
INC R2
ACALL DELAY 
DJNZ R0,LOOP0
SJMP MAIN


DELAY:
    MOV R3,#0FFH
LOOP2:   
    MOV    R4,#0FFH
LOOP1:
    DJNZ R4,LOOP1
    DJNZ R3,LOOP2
    RET   
	
	

END
	


