					ORG 00H
					LCALL 30H

					ORG 30H
					MOV P2,#0FFH
CONTINUE:		JNB P2.0, DIP1
					JNB P2.1, DIP2
					JNB P2.2, DIP3
					JNB P2.3, DIP4
					JNB P2.4, DIP5
					JNB P2.5, DIP6
					JNB P2.6, DIP7
					JNB P2.7, DIP8
					MOV P1,#0H
					SJMP CONTINUE
DIP1: 			SETB P1.0
					SJMP LAST
DIP2: 			SETB P1.1
					SJMP LAST
DIP3: 			SETB P1.2
					SJMP LAST
DIP4: 			SETB P1.3
					SJMP LAST
DIP5: 			SETB P1.4
					SJMP LAST
DIP6: 			SETB P1.5
					SJMP LAST
DIP7: 			SETB P1.6
					SJMP LAST
DIP8: 			SETB P1.7
LAST:			SJMP CONTINUE
					END